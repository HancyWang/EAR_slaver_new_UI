# Keil uVision project STM32F030Demo.uvprojx, settings and files
target Stm32f030demo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F071CBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F071 +hex
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\APP;..\OS;..\CORE;..\HARDWARE;..\MODULE;..\STM32F03x_FWLib\inc;..\STM32F03x_FWLib\src;..\User;..\SYSTEM;..\SYSTEM\cmd;..\SYSTEM\fifo
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group USER
    ./: main.c stm32f0xx_it.c system_stm32f0xx.c iwtdg.c
  group APP
    ../APP/: app.c comm_task.c key_led_task.c honeywell_sampling_data.c
  group MODULE
    ../MODULE/: protocol_module.c
  group SYSTEM
    ../APP/: common.c
    ../SYSTEM/: delay.c serial_port.c
    ../SYSTEM/fifo/: fifo.c
    ../SYSTEM/cmd/: CMD_Receive.c
  group HARDWARE
    ../APP/: i2c.c
    ../HARDWARE/: hardware.c Motor_pwm.c rtc.c
  group OS
    ../OS/: os_core.c
  group CORE
    ../CORE/: startup_stm32f0xx.s
  group STM32F03x_FWLib
    ../STM32F03x_FWLib/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_misc.c stm32f0xx_usart.c stm32f0xx_tim.c stm32f0xx_dma.c stm32f0xx_pwr.c stm32f0xx_flash.c stm32f0xx_adc.c stm32f0xx_exti.c stm32f0xx_syscfg.c stm32f0xx_iwdg.c stm32f0xx_rtc.c
software components: CMSIS:CORE 5.1.1
